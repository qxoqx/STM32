# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.0-Beta4\CMSIS\Driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./sources/: main.c led.h led.c uart.h uart.c delay.h delay.c stm32f10x_it.h stm32f10x_it.c key.h key.c flash.h flash.c spi.h spi.c dht11.h dht11.c ds18b20.h ds18b20.c adc.h adc.c i2c.h i2c.c bh1750.h bh1750.c soil.h soil.c co2.h co2.c pwm.h pwm.c
software components: CMSIS:CORE 5.0.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
